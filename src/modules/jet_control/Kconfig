## src/modules/jet_control/Kconfig
```kconfig
menuconfig MODULES_JET_CONTROL
	bool "jet_control"
	default y
	---help---
		Enable support for jet_control
```
